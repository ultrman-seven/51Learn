# Keil uVision project sjj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: sjj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\wy51Lib;.;..\wy51Lib\OLED;..\wy51Lib\SPI
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../wy51Lib/: common.c
    ../wy51Lib/SPI/: spiSoft.c
    ../wy51Lib/OLED/: oled.c font.c
